Commit message: added control script

File: urdf/rr_bot.xacro (robot description, xacro)
@@ -74,5 +74,5 @@
   <parent link="arm1_v5_1"/>
   <child link="arm2_v4_1"/>
-  <axis xyz="-0.0 1.0 0.0"/>
+  <axis xyz="-0.0 -1.0 0.0"/>
 </joint>
 </robot>
